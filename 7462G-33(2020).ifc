Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-07-14T18:08:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 14 18:08:09 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{FB625110-FA01-45C3-A9EA-FFEA99073F28}\ifc * Database version: 5507 * Database creation date: Tue Jul 14 18:08:08 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 14 18:08:08 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 14 18:08:08 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7462G-33 Shower faucet with spout, 7462G-33(2020):7462G-33 Shower faucet with spout:347215
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 150.5 mm; NominalHeight: 72.0282 mm; NominalWidth: 290 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 7462G-33(2020); ConvergoRefNr: 0087-2006-0048-FI; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 06/07/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150097614; EN Standard: EN 1111; LVI Number: 6310876; STF Certificate: VTT-RTH-00085-17; URL STF: http://static.oras.com/STF/7462G-33
Type - Identity Data(Type) - Catalog Drawing URL: http://static.oras.com/catdrw/7462G-33; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/7462G-33; FDV Document URL: http://www.oras.com/datasheet/7462G-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7462G-33; Group: Shower faucets; Manufacturer: Oras; Model: 7462G-33 Shower faucet with spout; Name_en: 7462G-33 Shower faucet with spout; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 294 x 164 x 83; Package Weight: 1.727 kg; Product Code: 7462G-33; Product Datasheet: http://www.oras.com/datasheet/7462G-33/en; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7462G-33; Product URL: http://static.oras.com/7462G-33; Technical DataSheet URL: http://www.oras.com/datasheet/7462G-33/en; Type Name: 7462G-33 Shower faucet with spout
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Aerator: CASCADE®; Connection Size: G1/2; Diverter: ;Integrated diverter / Volume control; Eco Flow At 300kPa: 0.00565035 m3/s; Flow Rate At 300kPa: 0.00812237 m3/s; Installation and Maintenance: http://static.oras.com/manual/7462G-33; Installation Type: Wall mounted; Installation Width: cc150 mm; Lever Handle: Temperature control handle;Flow control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Litter filter(s);Non-return valve(s);; Noise Class: I(ISO 3822); Pressure Loss With Flow 02ls: 230000 Pa; Shower Parts: EcoFlowControl; Spare Parts: http://static.oras.com/sp/7462G-33; Spout Type: Fixed spout; Temperature Adjustments: Thermostatic safety stop at 38°C
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Shower; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7462G-33(2020); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7462G-33; Name: 7462G-33 Shower faucet with spout; ReplacementCost: n/a; Shape: Sculptured; Size: 290x150x70 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7462G-33; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7462G-33 Shower faucet with spout
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0779416 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00316028 m3
Identity Data - Mark: 14
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 7462G-33(2020): 7462G-33 Shower faucet with spout; Family and Type: 7462G-33(2020): 7462G-33 Shower faucet with spout; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7462G-33(2020): 7462G-33 Shower faucet with spout; Type Id: 7462G-33(2020): 7462G-33 Shower faucet with spout; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
